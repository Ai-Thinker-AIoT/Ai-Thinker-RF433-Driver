# Keil uVision project AI8051U-AISG01.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8051U-8Bit Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x7FFF) IROM(0-0xFFFF) CLOCK(33177600)
  output: AI8051U-AISG01 +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: .\Source;.\Source\pan312x;.\Source\bsp;.\Source\hal_compat;.\Source\firmware;.\Toolchain\INC
  group User
    ./Source/: main.c
    ./Source/firmware/: at_command_firmware.c
  group BSP
    ./Source/bsp/: bsp.c bsp_timer.c bsp_uart.c bsp_led.c bsp_flash.c bsp.h bsp_timer.h bsp_uart.h bsp_led.h bsp_flash.h
  group HAL_COMPAT
    ./Source/hal_compat/: hal_compat.c hal_compat.h
  group PAN312x
    ./Source/pan312x/: PAN312x_Hal.c PAN312x_Driver.c PAN312x_Rf_CTK_Setting.c PAN312x_Hal.h PAN312x_Driver.h PAN312x_Rf_CTK_Setting.h PAN312x_xsfr.h
  group STARTUP
    ./Source/: port_int_vec.a51
  group INC
    ./Source/: stdint.h stdbool.h inttypes.h ai8051_port.h ctype.h stdio.h stdlib.h math.h XSFR_STC8051U_8Bit.H
